# IAR project TCC_v1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\Cássio Augusto Rosso\Google Drive\Engenharia Elétrica\VIII Semestre\Microprocessadores II\Lab\CASSIOROSSO\LAB_ARM\BIBLIOTECAS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: TCC_v1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../BIBLIOTECAS/driverlib/ewarm/Exe/: driverlib.a
    ../INTERRUPT/: startup_ewarm.c
    ./: TCC_v1.c
    ../../BIBLIOTECAS/utils/: uartstdio.c
